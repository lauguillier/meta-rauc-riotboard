FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-CONFIG_SYS_MMC_ENV_DEV-set-to-2-instead-of-0.patch"

