inherit setuptools3
require python-gbulb.inc
